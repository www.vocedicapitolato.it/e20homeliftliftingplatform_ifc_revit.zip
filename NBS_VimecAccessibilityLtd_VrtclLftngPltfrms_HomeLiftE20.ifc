Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-05-17T13:19:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon May 17 13:19:35 2021* Host: BIMServices* Database: C:\Users\PIOTRB~1\AppData\Local\Temp\{1AA2CAB2-37CB-4178-8894-774840633C49}\ifc* Database version: 5507* Database creation date: Mon May 17 13:19:18 2021* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon May 17 13:19:35 2021* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon May 17 13:19:35 2021* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcTransportElement: HomeLiftE20_1250x1000mm, NBS_VimecAccessibilityLtd_VrtclLftngPltfrms_HomeLiftE20:HomeLiftE20_1250x1000mm:315344
In: Level 0
Type - PredefinedType: ELEVATOR; Classification: Pr_65_80_47_95 (Uniclass2015); Material: NBS_VimecAccessibilityLtd_Vimec7040, NBS_VimecAccessibilityLtd_StainlessSteel, NBS_Glass_Single
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VimecAccessibilityLtd_VerticalLiftingPlatforms_HomeLiftE20_1250x1000mm; ManufacturerName: Vimec Accessibility Ltd; ManufacturerURL: www.vimechomelifts.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/xhzqvtbs; NBSDescription: Platform lifts; NBSReference: 90-80-65/350; ProductInformation: https://vimechomelifts.co.uk/home-lift/; Revision: n/a; Uniclass2015Title: Vertical lifting platforms; Uniclass2015Code: Pr_65_80_47_95; Uniclass2015Version: Products v1.20; Version: 1
Type - NBS_Data - Standard: n/a; RatedLoadMinimum: 400 kg; DriveType: Automatic; ControlDeviceType: Push button panel; ControlFeatures: Dead-man’s controls, size Ø32 mm, with Braille indications and blue backlighting; ElectricalSupply: Single Phase 240V 50Hz; Accessories: mechanical vertical full-height push-button panel, touch version vertical full-height push-button panel, stainless steel handle in two versions, round or square, flush version vertical mirror, flush version vertical glass, LCD display kit at floor, GSM telephone kit, I-button keys, speech synthesis, gong when floor is reached, cable and radio remote push-button panel at floor, access ramp; CarriageType: Fully enclosed; CarrierFrameMaterial: Various; CarrierFrameFinish: Vimec 7040 or, in alternative, in Vimec White; CarrierFrameColour: Vimec 7040 or, in alternative, in Vimec White; CarrierInfillMaterial: Steel or Glass; CarrierInfillFinish: Coated Steel Colur Type, Stainless Steel, Glass; CarrierInsertColour: Coated Steel Colur Type: Grey (STD), beige, blue, cherry, maple, matt white. Stainless Steel: Polished Linen, Brushed. Glass: Transparent or smoke Grey; DoorsArrangement: Single, Adjacent, Through; DoorsType: Hinged orTelescopic; DoorsClearOpeningWidthMinimum: Panel Door 600,650,700,750 Aluminium Panoramic Door 600,650,700,750 Double Himged Door 700,750 Automatic telescopic 2 panel door 700 Automatic telescopic 3 panel door 600, 650, 700,750 Automatic telescopic 4 panel door 750; DoorsFireRatingMinimum: 120 Mins (telescopic), 60 or 120 (Hinged); DoorsFrameMaterial: Panoramic aluminium with laminated glass; DoorsFrameFinish: Vimec 7040 or, in alternative, in Vimec White; DoorsFrameColour: Vimec 7040 or, in alternative, in Vimec White; DoorsInfillMaterial: Consult manufacturer; DoorsInfillFinish: White, Similinox (Telescopic) 441 Stainless Steel (telescopic) 316 Stainless Steel (telescopic) Vimec 7040, Special RAL; DoorsInfillColour: White, Similinox, Polished linen or brushed Stainless Steel, Special RAL; CarrierFloorDimensionsWidthMinimum: 1000mm; CarrierFloorDimensionsDepthMinimum: 1250mm; CarrierFloorMaterial: PVC, Linoleum, Flocked Floor (Carpet); CarrierFloorColour: PVC: Black Charcoal, Blonde Wood, Noce Wood, Grey Wood, Smooth Anthracite Linoleum: Ardesia Flocked Type: Smoth Palm,Grey Flotex Smooth; WorkingLoad: 400 kg; PitDepthOptions: 120 mm for masonry shaft and aluminium guards; 140 mm for metal framework; Applications: Any environment, whether a home or a public building; Speed: 0,15 m/sec; Motor: 1.5 kW; AuxiliaryCircuit: 24V-dc; SafetySystems: OSG and mechanical safety gear; LiftingSystem: Two lifting belts with spring system for load division; LiftingTravel: 14600 mm; AutomaticSafetyLevelling: n/a; HeadroomOptions: 2500 mm, 2600 mm if cabin supplied with automatic telescopic door; Transmission: With electric motor and belts; IntermediateStops: Max 4 with a minimum distance between the stops of 350 mm; WallFinishOptions: Robur wood, fabric, white squared, cloud, white wood, little homes; FloorFinishOptions: Smooth anthracite, grey wood, blonde wood, smooth palm, ardesia, noce wood; Fastening: With pre-mounted wall anchoring brackets, with back wall with mechanical anchors, with back wall with chemical anchors or with vertical I-beam, with metal frame
Type - Pset_TransportElementCommon - CapacityPeople: 5; CapacityWeight: 400; FireExit: no; Reference: n/a
Type - Pset_ElectricalDeviceCommon - HasProtectiveEarth: no; IK_Code: n/a; IP_Code: n/a; NominalFrequencyRange: n/a; NumberOfPoles: 0; PowerFactor: 0; RatedCurrent: 1.5 kW; RatedVoltage: 230 V
Type - IFC - IfcExportAs: IfcTransportElementType; IfcExportType: ELEVATOR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_65_80_47_95:Vertical lifting platforms; CodePerformance: n/a; Color: Vimec 7040, similinox, special RAL; Constituents: n/a; Description: Lifting system suitable for people with limited locomotory capacity; DurationUnit: year; ExpectedLife: 15 Years; Features: Internal or external application, on-board emergency push-button connected with an audible alarm and pre-set numbers (at the customer’s choice), integrated with the dial pad, thermal circuit breaker on the inverter, landing limit switch, over-run microswitch, pit and headroom under safety microswitches that inhibit the controls in the cabin and on the floor when activates, belt slackening/breaking safety device; Finish: Coated with stainless steel 441 for indoor installation and stainless steel 316 for outdoor installation; Grade: n/a; Manufacturer: info@vimec.biz; Material: E20; ModelNumber: E20; ModelReference: HomeLiftE20_1250x1000mm; Name: VerticalLiftingPlatforms_HomeLiftE20_1250x1000mm_VimecAccessibilityLtd; NominalHeight: 2000 mm; NominalLength: 1000 mm; NominalWidth: 1250 mm; ReplacementCost: n/a; Shape: n/a; Size: 2000 x 1250 x 1000 mm; SustainabilityPerformance: Consult manufacturer; WarrantyDescription: 2 Years warranty on parts; WarrantyDurationLabor: n/a; WarrantyDurationParts: included; WarrantyDurationUnit: 2 years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
